## sdkconfig.defaults
```kconfig
CONFIG_NN_OPTIMIZED=y
CONFIG_NN_SKIP_NUDGE=y
CONFIG_COMPILER_OPTIMIZATION_PERF=y
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240=y
```
